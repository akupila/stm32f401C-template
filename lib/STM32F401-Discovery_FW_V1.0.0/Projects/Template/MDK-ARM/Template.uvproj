# Keil uVision project Template.uvproj, settings and files
target Template (ARM-ADS)
  device: STM32F4_256KB STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF)  IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Template
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx,
  c include: .\..\;.\..\..\..\Libraries\CMSIS\Include;.\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\..\..\..\Utilities\STM32F401-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MDK-ARM
    ./../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xx.s
  group STM32F401-Discovery
    ./../../../Utilities/STM32F401-Discovery/: stm32f401_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ./../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ./../: main.c stm32f4xx_it.c system_stm32f4xx.c
