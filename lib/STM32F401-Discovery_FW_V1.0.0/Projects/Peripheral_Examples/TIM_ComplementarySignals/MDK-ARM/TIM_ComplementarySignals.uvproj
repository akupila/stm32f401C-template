# Keil uVision project TIM_ComplementarySignals.uvproj, settings and files
target TIM_ComplementarySignals (ARM-ADS)
  device: STM32F4_256KB STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF)  IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: TIM_ComplementarySignals
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx,
  c include: .\..\;.\..\..\..\..\Libraries\CMSIS\Include;.\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\..\..\..\..\Utilities\STM32F401-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MDK-ARM
    ./../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xx.s
  group STM32F401-Discovery
    ./../../../../Utilities/STM32F401-Discovery/: stm32f401_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ./../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_exti.c stm32f4xx_syscfg.c
  group User
    ./../: main.c stm32f4xx_it.c system_stm32f4xx.c
