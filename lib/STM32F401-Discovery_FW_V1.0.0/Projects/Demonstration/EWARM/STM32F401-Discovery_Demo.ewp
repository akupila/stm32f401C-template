# IAR project STM32F401-Discovery_Demo.ewp, settings and files
configuration STM32F401C-DISCO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401CC ST STM32F401CC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx; USE_USB_OTG_FS; USE_STM32F401; I2S_INTERRUPT
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\Utilities\STM32F401-Discovery
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F401-Discovery_Demo.hex
  ILINK.IlinkOutputFile: STM32F4-Discovery_Demo.out
  ILINK.IlinkIcfFile: stm32f401x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xx.s
  group STM32_USB_Device_Library/Class/hid
    ../../../Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
  group STM32_USB_Device_Library/Core
    ../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group STM32_USB_OTG_Driver
    ../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group STM32F401_Discovery
    ../../../Utilities/STM32F401-Discovery/: stm32f401_discovery.c stm32f401_discovery_audio_codec.c stm32f401_discovery_l3gd20.c stm32f401_discovery_lsm303dlhc.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group User
    ../: main.c selftest.c stm32f4xx_it.c system_stm32f4xx.c usb_bsp.c usbd_desc.c usbd_usr.c
