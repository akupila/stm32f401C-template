<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\Demonstration\EWARM\STM32F401-Discovery_Demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\FW_upgrade\EWARM\STM32F401-Discovery_FW_Upgrade.ewp</path>
  </project>
    <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\ADC_DMA\EWARM\ADC_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\DMA_FLASHToRAM\EWARM\DMA_FLASHToRAM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\EXTI_Example\EWARM\EXTI_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\FLASH_Program\EWARM\Flash_Program.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\FLASH_WriteProtection\EWARM\Flash_Write_Protection.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\GPIO_IOToggle\EWARM\GPIO_IOToggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\IWDG_Example\EWARM\IWDG_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\MEMS_L3GD20\EWARM\L3GD20.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_CurrentConsumption\EWARM\PWR_CurrentConsumption.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_STANDBY\EWARM\PWR_STANDBY.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_STOP\EWARM\PWR_STOP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\RCC_Example\EWARM\RCC_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\SysTick_Example\EWARM\SysTick_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_ComplementarySignals\EWARM\TIM_ComplementarySignals.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_PWM_Input\EWARM\TIM_PWM_Input.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_PWM_Output\EWARM\TIM_PWM_Output.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_TimeBase\EWARM\TIM_TimeBase.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Template\EWARM\Template.ewp</path>
  </project>
  <batchBuild/>
</workspace>


