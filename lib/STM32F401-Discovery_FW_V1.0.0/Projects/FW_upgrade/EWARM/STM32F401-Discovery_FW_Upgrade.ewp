# IAR project STM32F401-Discovery_FW_Upgrade.ewp, settings and files
configuration FW_Upgrade_Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xC ST STM32F401xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Utilities\Third_Party\fat_fs\inc; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\Utilities\STM32F401-Discovery; ..\..\..\Utilities\Third_Party\fat_fs\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F4-Discovery_FW_Upgrade.bin
  ILINK.IlinkOutputFile: FW_Upgrade_Demo.out
  ILINK.IlinkIcfFile: stm32f401x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xx.s
  group FAT_FS
    ../src/: fattime.c
    ../../../Utilities/Third_Party/fat_fs/src/: ff.c
  group STM32_USB_HOST_Library/Class/MSC
    ../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group STM32_USB_HOST_Library/Core
    ../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group STM32_USB_OTG_Driver
    ../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group STM32F4_Discovery
    ../../../Utilities/STM32F401-Discovery/: stm32f401_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group User
    ../src/: command.c flash_if.c main.c stm32f4xx_it.c system_stm32f4xx.c usb_bsp.c usbh_usr.c
